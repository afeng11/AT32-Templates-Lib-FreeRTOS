# Keil uVision project Template-FreeRTOS.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.3
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template-Libs +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=1 v6Lto=1 wLevel=3
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER
  c include: .\user-source\include;.\presets\include;.\drivers\inc;.\cmsis;.\startup;.\freertos;.\freertos\include
  asm include: ..\Template-Libs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user-src
    ./user-source/: main.c
  group presets
    ./presets/: systick_delay.c at32f403a_clock.c at32f403a_int.c
  group drivers
    ./drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group startup
    ./startup/: system_at32f403a_407.c startup_at32f403a_407.s
  group FreeRTOS
    ./freertos/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_4.c
